Commit message: Update pin.urdf

File: bowling/urdf/pin.urdf (robot description, URDF)
Before this commit: robot pin_urdf, 2 links, 1 joints
Links:
- link base_link: geometry collision mesh filename=package://bowling/mesh/pin.dae; visual mesh filename=package://bowling/mesh/pin.dae
